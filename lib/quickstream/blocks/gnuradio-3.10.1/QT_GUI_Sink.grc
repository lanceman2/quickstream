options:
  parameters:
    generate_options: qt_gui
    id: QT_GUI_Sink
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: qtgui_sink
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: scope
    type: complex
  states: {}
- name: stdin
  id: blocks_file_descriptor_source
  parameters:
    fd: '0'
    repeat: 'False'
    type: complex
  states: {}

connections:
- [stdin, '0', qtgui_sink, '0']

metadata:
  file_format: 1
